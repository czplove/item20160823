<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TemperatureHumiditySensor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>TemperatureHumiditySensor</name>
      <member>
        <project>TemperatureHumiditySensor</project>
        <configuration>Normal</configuration>
      </member>
      <member>
        <project>TemperatureHumiditySensor</project>
        <configuration>SHT30</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


