<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ContactSwitch.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ContactSwitch</name>
      <member>
        <project>ContactSwitch</project>
        <configuration>netvox</configuration>
      </member>
      <member>
        <project>ContactSwitch</project>
        <configuration>PCB_Antenna</configuration>
      </member>
      <member>
        <project>ContactSwitch</project>
        <configuration>SteelDisc_Antenna</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


