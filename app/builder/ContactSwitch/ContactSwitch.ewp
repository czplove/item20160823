# IAR project ContactSwitch.ewp, settings and files
configuration PCB_Antenna (ARM, debug)
  General.OGChipSelectEditMenu: EM357 SiliconLaboratories EM357
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ContactSwitch/ContactSwitch_endpoint_config.h"; BOARD_HEADER="app\builder\ContactSwitch\ContactSwitch_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ContactSwitch/ContactSwitch_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ContactSwitch/ContactSwitch.h"; __SOURCEFILE__="$FILE_FNAME$"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; CONTACT_SWITCH_PCB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\framework\include; ..\..\..\app\util; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ContactSwitch/ContactSwitch_endpoint_config.h"; BOARD_HEADER="app\builder\ContactSwitch\ContactSwitch_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ContactSwitch/ContactSwitch_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ContactSwitch/ContactSwitch.h"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\app\util; ..\..\..\hal; ..\..\..\hal\..
  OBJCOPY.OOCOutputFile: ContactSwitch-Pcb.hex
  postbuild: ContactSwitch.bat $TARGET_BPATH$
  ILINK.IlinkOutputFile: ContactSwitch.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\hal\micro\cortexm3\em35x\em357\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
configuration SteelDisc_Antenna (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ContactSwitch/ContactSwitch_endpoint_config.h"; BOARD_HEADER="app\builder\ContactSwitch\ContactSwitch_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ContactSwitch/ContactSwitch_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ContactSwitch/ContactSwitch.h"; __SOURCEFILE__="$FILE_FNAME$"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; CONTACT_SWITCH_STEELDISC
  OBJCOPY.OOCOutputFile: ContactSwitch-steeldisc.hex
configuration netvox (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; NULL_BTL; CORTEXM3; CORTEXM3_EMBER_MICRO; CORTEXM3_EM357; PHY_EM3XX; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/ContactSwitch/ContactSwitch_endpoint_config.h"; BOARD_HEADER="app\builder\ContactSwitch\ContactSwitch_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/ContactSwitch/ContactSwitch_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/ContactSwitch/ContactSwitch.h"; __SOURCEFILE__="$FILE_FNAME$"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"; CONTACT_SWITCH_NETVOX
  OBJCOPY.OOCOutputFile: ContactSwitch-Netvox.hex
  group (top)
    ../../../hal/micro/cortexm3/: adc.c assert-crash-handlers.c button-interface.c button.c buzzer.c cstartup-common.c diagnostic.c ext-device.c faults.s79 generic-interrupt-control.c gpio-sensor.c isr-stubs.s79 led-blink.c led.c mfg-token.c micro-common.c micro.c mpu.c sleep.c spi-master.c tamper-switch.c token-def.c token.c uart.c
    ../../framework/plugin/address-table/: address-table-cli.c address-table.c
    ../../framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c message.c multi-network.c print-formatter.c print.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c time-util.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../../hal/micro/generic/: antenna-stub.c crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../framework/plugin/basic/: basic.c
    ./: call-command-handler.c callback-stub.c cli.c ContactSwitch_callbacks.c stack-handler-stub.c
    ../../../hal/micro/cortexm3/usb/cdc/: callbacks.c descriptors.c
    ../../util/serial/: command-interpreter2.c ember-printf.c serial.c
    ../../framework/plugin-soc/connection-manager/: connection-manager-cli.c connection-manager.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../framework/plugin/diagnostic-server/: diagnostic-server-soc.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../hal/: ember-configuration.c
    ../../framework/plugin/end-device-support/: end-device-move.c end-device-support-cli.c end-device-support.c polling-common.c polling-soc.c
    ../../framework/plugin/ezmode-commissioning/: ez-mode-cli.c ez-mode.c
    ../../framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../util/common/: form-and-join-node-adapter.c form-and-join.c library.c
    ../../framework/plugin/ias-zone-server/: ias-zone-server-cli.c ias-zone-server.c
    ../../framework/plugin/identify/: identify-cli.c identify.c
    ../../framework/plugin-soc/idle-sleep/: idle-sleep-cli.c idle-sleep-soc.c idle-sleep.c
    ../../framework/plugin-soc/low-voltage-shutdown/: lv-shutdown-cli.c lv-shutdown.c
    ../../framework/plugin-soc/manufacturing-library-cli/: manufacturing-library-cli.c
    ../../framework/plugin/network-find/: network-find.c
    ../../framework/plugin/poll-control-server/: poll-control-server.c
    ../../framework/plugin/reporting/: reporting-cli.c reporting.c
    ../../util/security/: security-address-cache.c
    ../../framework/plugin-soc/security-sensor/: security-sensor.c
    ../../framework/plugin/simple-main/: simple-main.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group Libraries
    ../../../build/alarm-library-cortexm3-iar-em357-em3xx/: alarm-library.a
    ../../../build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-em357-em3xx/: cbke-283k1-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-283k1-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-em357-em3xx/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../build/debug-basic-library-cortexm3-iar-em357-em3xx/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-em357-em3xx/: debug-extended-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-em357-em3xx/: enhanced-beacon-request-stub-library.a
    ../../../build/gp-stub-library-cortexm3-iar-em357-em3xx/: gp-stub-library.a
    ../../../build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../build/mfglib-library-cortexm3-iar-em357-em3xx/: mfglib-library.a
    ../../../build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-em357-em3xx/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-em357-em3xx/: sim-eeprom1-library.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
